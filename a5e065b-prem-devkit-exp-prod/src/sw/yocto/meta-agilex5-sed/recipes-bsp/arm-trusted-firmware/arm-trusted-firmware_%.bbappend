COMPATIBLE_MACHINE:append = "|agilex5_dk_a5e065bb32a"
ATFPLAT:agilex5_dk_a5e065bb32a = "agilex5"
