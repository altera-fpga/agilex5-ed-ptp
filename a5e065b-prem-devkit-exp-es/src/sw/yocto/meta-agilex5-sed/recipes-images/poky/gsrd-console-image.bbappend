IMAGE_INSTALL:append = " packetgenerator packetswitch scripts"
IMAGE_INSTALL:append = " iperf3 bridge-utils util-linux expect tzdata coreutils"
